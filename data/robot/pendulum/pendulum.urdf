Commit message: Update

File: data/robot/pendulum/pendulum.urdf (robot description, URDF)
Before this commit: robot simple_pendulum, 3 links, 2 joints
Links:
- link pendulum_end: mass 1.0 -> 2.0
